## Config.in
```kconfig
mainmenu_option next_comment
comment 'Comedi'

tristate "Comedi support" CONFIG_COMEDI
if [ "$CONFIG_COMEDI" != "n" ]; then
  source comedi/Config.in
fi

endmenu
```
